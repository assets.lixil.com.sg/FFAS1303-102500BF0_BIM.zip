Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-01-11T00:57:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 11 00:57:22 2024 * Host: LAPTOP-TVR8NT0T * Database: C:\Users\user\AppData\Local\Temp\168759b8-236a-4fb5-8db2-4d8359ac085b\54241107-5ddb-4aae-ad4c-041296e2e5fb\ifc * Database version: 5507 * Database creation date: Thu Jan 11 00:57:21 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 11 00:57:22 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 11 00:57:22 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: FFAS1303-102500BF0_REVIT:Acacia E 3H Dual Control, FFAS1303-102500BF0_REVIT:Acacia E 3H Dual Control:5064
In: Level 1
Type - Material: Steel, Chrome Plated
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: Acacia E 3H Dual Control
Pset_DistributionFlowElementCommon - Reference: Acacia E 3H Dual Control; sets with these values: 2
